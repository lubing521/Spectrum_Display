# IAR project Spectrum_Display.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F4; STM32F407xx
  ICCARM.CCIncludePath2: ../app; ../Drivers/CMSIS/Include; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../hardware/delay; ../hardware/GUI; ../hardware/key; ../hardware/lcd_drive; ../hardware/led; ../hardware/touch; ../Inc; ../page; ../hardware/w25q64
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Spectrum_Display.srec
  ILINK.IlinkOutputFile: Spectrum_Display.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app.c
    ../page/: page.c
  group common
    ../Src/: common.c dma.c fsmc.c gpio.c usart.c
    ../hardware/delay/: delay.c
  group drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_rcc.c
  group lcd
    ../hardware/GUI/: GUI.c
    ../hardware/lcd_drive/: lcd_drive.c
    ../hardware/touch/: touch.c
  group source
    ../Src/: main.c
  group startup
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../Src/: stm32f4xx_hal_msp.c system_stm32f4xx.c
